Type	/Altmode /Backspace
Type:TI	/Altmode /Backspace /Device:Ti82 /Indent:8 /Name
When	/MULTI Fletcherc, Carl, Osman, Wilkes, -
	Wrs, Ndt, SliSys
NeWhen	/MULTI CARL, -
	TSUCOOP, OSMAN, WILKES, -
	YEUX, VUE, -
	WRS, NDT, MATOKA, SLISYS
XLogon	/Info:All /Notify:All
Logon	/Info:All /Notify:(users,warn) -
	/Set:mode pdp,No Att,alp (mpl)zen,scm (xexec)mexec -
	/Users:([3,*],[14717,*],[11016,*],[43511,*]) -
	/Tt:lc def w 80 bsd n cr bac xon er n del rbs rt for typ WHAT -
	/sel:HACK:Node:3456 -
	/sel:HP2621:Node:6657-1,2770-5 -
	/sel:ADM3A:Node:6760-4,115-4,10115-4 -
	/sel:VT102:Node:2770-4 -
	/sel:LIBERTY:Node:6657,2346,2770,6760,115,10115 -
	/sel:PRINTER:Node:3143-006,3143-034,3143-000 -
	/sel:PAYMENT:Node:3143,3146  /sel:FREMONT:Node:3220 -
	/sel:MUX:Node:2366,2367  /sel:OAKLAND:Node:4175 -
	/sel:CUPERTINO:Node:2563,3335,2242,2243 /sel:SANJOSE:Node:4165 -
	/sel:SANTACLARA:Node:2470 /sel:CUPC:Node:2457 /sel:TUCSON:Node:3721 -
	/sel:BUBBNET:Node:7344,7345,7346,7347,6024,7350,7351,7353,7354

Logon:HACK	/Te:"Dumb Micronode *HACK*  Jacksonville, Florida" -
		/Tt:n for typ HP2621 w 80 /hp2621

Logon:ADM3A	/Te:"Dumb TTY"  /Tt:typ ADM3A  w 80  for
Logon:BUBBNET	/Te:"BubbNet"   /Tt:typ TI820  w 132 for
Logon:CRT	/Te:"Glass TTY" /Tt:typ CRT    w 80
Logon:CUPC	/Te:"DECwriter" /Tt:typ LA36   w 80  n for n tab n era
Logon:CUPERTINO	/Te:"Cupertino" /Tt:typ HP2621 w 80  n for /hp2621
Logon:FREMONT	/Te:"Fremont"   /Tt:typ HP2621 w 80  n for /hp2621
Logon:HP2621	/Te:"Office!"   /Tt:typ HP2621 w 80  n for /hp2621
Logon:LIBERTY	/Te:"Liberty"   /Tt:typ HP2621 w 80  n for /hp2621
Logon:MUX	/Te:"Tymnet-Mux"/Tt:typ HP2621 w 80  n for /hp2621
Logon:OAKLAND	/Te:"Oakland"   /Tt:typ HP2621 w 80  n for /hp2621
Logon:PAYMENT	/Te:"Payment"   /Tt:typ HP2621 w 80  n for /hp2621
Logon:PRINTER	/Te:"Printer"   /Tt:typ TI820  w 132 for
Logon:SANJOSE   /Te:"San-Jose"  /Tt:typ HP2621 w 80  n for /hp2621
Logon:SANTACLARA/Te:"SantaClara"/Tt:typ HP2621 w 80  n for /hp2621
Logon:TUCSON	/Te:"Tucson!"   /Tt:typ VT100  w 80  for
Logon:VT102	/Te:"Rainbow"   /Tt:typ VT102  w 132 for crlf
